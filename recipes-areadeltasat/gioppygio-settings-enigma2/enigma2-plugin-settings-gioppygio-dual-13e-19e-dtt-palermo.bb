SUMMARY = "GioppyGio Dual Feeds DTT Palermo E2 Settings File"

SETTINGS_FILENAME = "Dual-13E-19E-DTT-Palermo"

include settings-GioppyGio.inc
