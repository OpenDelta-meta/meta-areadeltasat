SUMMARY = "GioppyGio Trial-13E-16E-19E E2 Settings File"

SETTINGS_FILENAME = "Trial-13E-16E-19E"

include settings-GioppyGio.inc
