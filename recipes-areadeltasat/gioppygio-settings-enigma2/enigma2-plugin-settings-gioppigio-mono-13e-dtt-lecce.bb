SUMMARY = "GioppyGio Mono-13E-DTT-Lecce E2 Settings File"

SETTINGS_FILENAME = "Mono-13E-DTT-Lecce"

include settings-GioppyGio.inc
