SUMMARY = "GioppyGio Feeds DTT Napoli E2 Settings File"

SETTINGS_FILENAME = "Dual-13E-19E-DTT-Napoli"

include settings-GioppyGio.inc
