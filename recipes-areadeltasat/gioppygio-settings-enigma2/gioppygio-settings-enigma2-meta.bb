require conf/license/license-gplv2.inc

DESCRIPTION = "meta file for settings"

inherit allarch

DEPENDS = "\
    enigma2-plugin-settings-gioppigio-mono-13e \
	enigma2-plugin-settings-gioppygio-dual-13e-19e \
    enigma2-plugin-settings-gioppygio-dual-13e-19e-dtt-napoli \
	enigma2-plugin-settings-gioppygio-dual-13e-19e-dtt-enna \
	enigma2-plugin-settings-gioppygio-dual-13e-19e-dtt-lecce \
	enigma2-plugin-settings-gioppygio-dual-13e-19e-dtt-milano \
    enigma2-plugin-settings-gioppygio-dual-13e-19e-dtt-palermo \
    enigma2-plugin-settings-gioppygio-mono-13e-dtt-palermo \
    enigma2-plugin-settings-gioppigio-mono-13e-dtt-enna \
    enigma2-plugin-settings-gioppigio-mono-13e-dtt-lecce \
    enigma2-plugin-settings-gioppigio-mono-13e-dtt-milano \
    enigma2-plugin-settings-gioppigio-mono-13e-dtt-napoli \
    enigma2-plugin-settings-gioppigio-mono-13e-dtt-roma \
    enigma2-plugin-settings-gioppigio-mono-13e-dtt-torino \
    enigma2-plugin-settings-gioppigio-motor-75e-45w \
    enigma2-plugin-settings-gioppigio-trial-13e-16e-19e \
	"
