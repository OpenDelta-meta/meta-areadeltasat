SUMMARY = "GioppyGio Mono-13E-DTT-Roma E2 Settings File"

SETTINGS_FILENAME = "Mono-13E-DTT-Roma"

include settings-GioppyGio.inc
