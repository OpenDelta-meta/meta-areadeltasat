SUMMARY = "GioppyGio Dual Feeds DTT Enna E2 Settings File"

SETTINGS_FILENAME = "Dual-13E-19E-DTT-Enna"

include settings-GioppyGio.inc
