SUMMARY = "GioppyGio Dual Feeds DTT-Lecce E2 Settings File"

SETTINGS_FILENAME = "Dual-13E-19E-DTT-Lecce"

include settings-GioppyGio.inc
