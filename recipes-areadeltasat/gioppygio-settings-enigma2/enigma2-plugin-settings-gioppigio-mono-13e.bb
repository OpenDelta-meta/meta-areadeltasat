SUMMARY = "GioppyGio Mono-13E E2 Settings File"

SETTINGS_FILENAME = "Mono-13E"

include settings-GioppyGio.inc
