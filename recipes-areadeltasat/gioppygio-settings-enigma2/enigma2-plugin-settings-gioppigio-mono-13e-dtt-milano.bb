SUMMARY = "GioppyGio Mono-13E-DTT-Milano E2 Settings File"

SETTINGS_FILENAME = "Mono-13E-DTT-Milano"

include settings-GioppyGio.inc
