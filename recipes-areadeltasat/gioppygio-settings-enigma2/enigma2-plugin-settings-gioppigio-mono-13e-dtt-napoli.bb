SUMMARY = "GioppyGio Mono-13E-DTT-Napoli E2 Settings File"

SETTINGS_FILENAME = "Mono-13E-DTT-Napoli"

include settings-GioppyGio.inc
