SUMMARY = "GioppyGio Dual Feeds E2 Settings File"

SETTINGS_FILENAME = "Dual-13E-19E"

include settings-GioppyGio.inc
