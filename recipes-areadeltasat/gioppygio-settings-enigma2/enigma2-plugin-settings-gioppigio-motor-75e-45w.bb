SUMMARY = "GioppyGio Motor-75E-45W E2 Settings File"

SETTINGS_FILENAME = "Motor-75E-45W"

include settings-GioppyGio.inc
