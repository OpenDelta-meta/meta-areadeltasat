SUMMARY = "GioppyGio Dual Feeds DTT-Milano E2 Settings File"

SETTINGS_FILENAME = "Dual13E-19E-DTT-Milano"

include settings-GioppyGio.inc
