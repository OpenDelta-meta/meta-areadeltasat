SUMMARY = "GioppyGio Mono-13E-DTT-Enna E2 Settings File"

SETTINGS_FILENAME = "Mono-13E-DTT-Enna"

include settings-GioppyGio.inc
