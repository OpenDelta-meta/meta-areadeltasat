SUMMARY = "GioppyGio Mono-13E-DTT-Palermo E2 Settings File"

SETTINGS_FILENAME = "Mono-13E-DTT-Palermo"

include settings-GioppyGio.inc
