SUMMARY = "GioppyGio Mono-13E-DTT-Torino E2 Settings File"

SETTINGS_FILENAME = "Mono-13E-DTT-Torino"

include settings-GioppyGio.inc
