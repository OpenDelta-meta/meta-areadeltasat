require conf/license/license-gplv2.inc

DESCRIPTION = "meta file for settings"

inherit allarch

DEPENDS = "\
	enigma2-plugin-settings-vhannibal.hotbird.and.dtt.italia \
	enigma2-plugin-settings-vhannibal.dual.feeds.and.dtt.italia \
	enigma2-plugin-settings-vhannibal.motor.and.dtt.italia \
	enigma2-plugin-settings-vhannibal.hotbird \
	enigma2-plugin-settings-vhannibal.dual.feeds \
	enigma2-plugin-settings-vhannibal.motor \
	enigma2-plugin-settings-vhannibal.trial-30-ovest \
	enigma2-plugin-settings-vhannibal-quadri-multistream \
    enigma2-plugin-settings-vhannibal-multi-9-13-16-19-23-28-est \
	"
