SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Multi-9-13-16-19-23-28-est"

include settings-vhannibal.inc
